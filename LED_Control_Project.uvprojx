# Keil uVision project LED_Control_Project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED_Control_Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group |_APPLICATION
    ./COTS/APPLICATION/: main.c main.h
  group |__LED_Control_APP
    ./COTS/APPLICATION/LED_Control_APP/: APP.c APP.h
  group |___USER
    ./COTS/APPLICATION/LED_Control_APP/USER/: USER.h USER.c
  group |___BLINKING
    ./COTS/APPLICATION/LED_Control_APP/BLINKING/: BLINKING.c BLINKING.h
  group |___SERVICES
    ./COTS/APPLICATION/LED_Control_APP/SERVICES/: Config.h
  group |____DISPLAY
    ./COTS/APPLICATION/LED_Control_APP/SERVICES/DISPLAY/: DISPLAY.c DISPLAY.h
  group |____INPUT
    ./COTS/APPLICATION/LED_Control_APP/SERVICES/INPUT/: INPUT.c INPUT.h
  group |____TIME
    ./COTS/APPLICATION/LED_Control_APP/SERVICES/TIME/: TIME.c TIME.h
  group |_MCAL
    ./COTS/MCAL/: Utilities.h
  group |__DIO
    ./COTS/MCAL/DIO/: DIO.c DIO.h
  group |__INTERRUPT
    ./COTS/MCAL/INTERRUPT/: interrupt.c interrupt.h
  group |__PORT
    ./COTS/MCAL/PORT/: port.c port.h
  group |__SYSTICK
    ./COTS/MCAL/SYSTICK/: SYSTICK.c SYSTICK.h
  group |__BUTTON
    ./COTS/ECUAL/BUTTON/: BUTTON.c BUTTON.h
  group |__LED
    ./COTS/ECUAL/LED/: LED.c LED.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
